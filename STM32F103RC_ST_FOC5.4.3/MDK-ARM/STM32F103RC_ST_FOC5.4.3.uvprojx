# Keil uVision project STM32F103RC_ST_FOC5.4.3.uvprojx, settings and files
target STM32F103RC_ST_FOC5.4.3 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F030R8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: STM32F103RC_ST_FOC5.4.3 +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM0,USE_HAL_DRIVER,STM32F030x8
  c include: ../Inc;    ../Drivers/STM32F0xx_HAL_Driver/Inc;    ../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;    ../MCSDK_v5.4.3-Full/MotorControl/MCSDK/MCLib/Any/Inc;    ../MCSDK_v5.4.3-Full/MotorControl/MCSDK/MCLib/F0xx/Inc;    ../MCSDK_v5.4.3-Full/MotorControl/MCSDK/UILibrary/Inc;    ../MCSDK_v5.4.3-Full/MotorControl/MCSDK/SystemDriveParams;    ../Drivers/CMSIS/Device/ST/STM32F0xx/Include;    ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f030x8.s
  group Application/User
    ../Src/: main.c motorcontrol.c mc_api.c motor_control_protocol.c mc_config.c mc_tasks.c regular_conversion_manager.c mc_math.c mc_interface.c stm32f0xx_mc_it.c mc_parameters.c ui_task.c user_interface.c dac_rctimer_ui.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_exti.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Middlewares/MotorControl
    ../MCSDK_v5.4.3-Full/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c circle_limitation.c digital_output.c fast_div.c hall_speed_pos_fdbk.c motor_power_measurement.c ntc_temperature_sensor.c open_loop.c pid_regulator.c pqd_motor_power_measurement.c pwm_curr_fdbk.c pwm_common.c r_divider_bus_voltage_sensor.c ramp_ext_mngr.c revup_ctrl.c speed_pos_fdbk.c speed_torq_ctrl.c state_machine.c virtual_speed_sensor.c
    ../MCSDK_v5.4.3-Full/MotorControl/MCSDK/MCLib/F0xx/Src/: r3_f0xx_pwm_curr_fdbk.c
    ../MCSDK_v5.4.3-Full/MotorControl/MCSDK/UILibrary/Src/: dac_common_ui.c frame_communication_protocol.c ui_irq_handler.c usart_frame_communication_protocol.c
software components: CMSIS:CORE 4.3.0
